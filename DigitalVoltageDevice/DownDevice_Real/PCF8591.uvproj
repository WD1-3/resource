# Keil uVision project PCF8591.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: PCF8591 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\AD_IIC;.\user;.\lcd12864;.\Segment;.\output;.\uart;.\Hardware
  group user
    ./user/: main.c main.h
  group AD_IIC
    ./AD_IIC/: I2C.c I2C.h
  group uart
    ./uart/: UART.h UART.c
  group Segment
    ./Segment/: segments.c segments.h
  group Hardware
    ./Hardware/: tim2.c tim2.h key.c key.h beep.c beep.h
